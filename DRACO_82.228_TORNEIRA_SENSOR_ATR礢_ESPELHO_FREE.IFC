Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_82.228_TORNEIRA_SENSOR_ATRÁS_ESPELHO_FREE.IFC
Time: 2022-12-21T17:27:53
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_82.228-1_CHAPA_DE_APOIO_Default
In: Default Storey
Material: 1060 Alloy

# IfcBuildingElementProxy: DRACO_82.228-2_BICA_Default
In: Default Storey
Material: 1060 Alloy

# IfcBuildingElementProxy: DRACO_82.228-3_DISCO_INTERNO_Default
In: Default Storey
Material: Nylon 101

# IfcBuildingElementProxy: DRACO_82.228-4_EIXO_CENTRAL_ROSCADO_Default
In: Default Storey
Material: Brass

# IfcBuildingElementProxy: DRACO_82.228-5_PORCA_SEXTAVADA_ROSCADA_Default
In: Default Storey
Material: Brass

# IfcBuildingElementProxy: DRACO_82.228-6_CONTRA-PORCA_SEXTAVADA_Default
In: Default Storey
Material: AISI 1020

# IfcBuildingElementProxy: DRACO_82.228-7_ELETRO_VÁLVULA_Default
In: Default Storey
Material: PA Type 6

# IfcBuildingElementProxy: DRACO_82.228-9_SENSOR_INFRAVERMELHO_Default
In: Default Storey
Material: PVC 0.007 Plasticized
